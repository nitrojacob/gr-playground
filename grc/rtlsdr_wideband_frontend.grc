options:
  parameters:
    author: gr-playground agent
    comment: Pure Wideband Live RTL-SDR Capture Frontend with Push Button Recording Control
    description: Live RTL-SDR RF pure wideband raw capture with interactive GUI frequency tuning and Push Button Start/Stop capture controls
    generate_options: qt_gui
    id: rtlsdr_wideband_frontend
    output_language: python
    title: Pure Wideband Live RTL-SDR Capture Frontend with Push Button Recording Control
  states: {}

blocks:
- name: capture_enable
  id: variable_qtgui_push_button
  parameters:
    comment: Start/Stop Capture Recording Push Button (Off by default = 0)
    label: Start / Stop Capture
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: center_freq_mhz
  id: variable_qtgui_range
  parameters:
    comment: Center Frequency Adjustment Slider
    label: Center Frequency (MHz)
    start: '8.0'
    step: '1.0'
    stop: '2000'
    value: '100.0'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    comment: Hardware RF Gain Slider
    label: IF Gain (dB)
    start: '0.0'
    step: '1.0'
    stop: '40'
    value: '20'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: Hardware RF Gain Slider
    label: RF Tuner Gain (dB)
    start: '0.0'
    step: '1.0'
    stop: '49.6'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Wideband Hardware Sampling Rate
    value: '2048000'
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    comment: Start/Stop Gated Recording Copy Block
    enabled: bool(capture_enable)
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq_mhz*1e6
    fftsize: '1024'
    name: '"Wideband Spectrum (RTL-SDR)"'
    showrf: 'True'
    type: complex
  states: {}
- name: rtlsdr_source
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    comment: Live RTL-SDR Hardware Source (gr-osmosdr native)
    freq0: center_freq_mhz*1e6
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: wideband_file_sink
  id: blocks_file_sink
  parameters:
    comment: Pure Wideband Spectrum File Sink (2.4 MSps Raw SigMF Data)
    file: /tmp/wideband_raw_capture.sigmf-data
    type: complex
  states: {}

connections:
- [blocks_copy_0, '0', wideband_file_sink, '0']
- [rtlsdr_source, '0', blocks_copy_0, '0']
- [rtlsdr_source, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
