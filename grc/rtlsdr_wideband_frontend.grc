options:
  parameters:
    author: gr-playground agent
    comment: Single Unified RTL-SDR Live Capture & Wideband Channelizer Frontend
    description: Live RTL-SDR RF capture and wideband file channelizer exporting to SigMF
    generate_options: qt_gui
    id: rtlsdr_wideband_frontend
    output_language: python
    title: RTL-SDR Wideband Capture & Channelizer Frontend
  states: {}

blocks:
- name: channel_freq_offset
  id: variable_qtgui_range
  parameters:
    label: Channel Offset (Hz)
    range_Type: float
    start: '-1000000.0'
    step: '1000.0'
    stop: '1000000.0'
    value: '200000.0'
  states: {}
- name: channel_cutoff
  id: variable_qtgui_range
  parameters:
    label: Channel Cutoff (Hz)
    range_Type: float
    start: '5000.0'
    step: '2500.0'
    stop: '250000.0'
    value: '60000.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: channel_cutoff
    gain: '1.0'
    samp_rate: samp_rate
    width: channel_cutoff * 0.2
    win: window.WIN_HAMMING
  states: {}
- name: rtlsdr_source
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 100.0e6
    comment: Live RTL-SDR Hardware Capture Source
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: qtgui_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    comment: Wideband Spectrum Visualizer
    fc: 100.0e6
    fftsize: '2048'
    grid: 'True'
    label1: Wideband Spectrum
    name: '"Wideband Spectrum (RTL-SDR)"'
    norm_maxk: '-1'
    type: complex
  states: {}
- name: freq_xlating_filter
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: channel_freq_offset
    comment: Digital Downconverter (DDC) Channelizer
    decim: '10'
    samp_rate: samp_rate
    taps: lpf_taps
    type: ccc
  states: {}
- name: agc
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    comment: Automatic Gain Control
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: sigmf_file_sink
  id: blocks_file_sink
  parameters:
    comment: Export Extracted Narrowband Channel to SigMF Data
    file: /tmp/extracted_channel.sigmf-data
    type: complex
  states: {}

connections:
- [rtlsdr_source, '0', qtgui_freq_sink, '0']
- [rtlsdr_source, '0', freq_xlating_filter, '0']
- [freq_xlating_filter, '0', agc, '0']
- [agc, '0', sigmf_file_sink, '0']

metadata:
  file_format: 1
