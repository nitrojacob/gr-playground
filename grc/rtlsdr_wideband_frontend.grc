options:
  parameters:
    author: gr-playground agent
    comment: Pure Wideband Live RTL-SDR Capture Frontend with Push Button Recording Control
    description: Live RTL-SDR RF pure wideband raw capture with interactive GUI frequency tuning and Push Button Start/Stop capture controls
    generate_options: qt_gui
    id: rtlsdr_wideband_frontend
    output_language: python
    title: Pure Wideband Live RTL-SDR Capture Frontend with Push Button Recording Control
  states: {}

blocks:
- name: capture_enable
  id: variable_qtgui_toggle_button_msg
  parameters:
    comment: Start/Stop Capture Recording Toggle Button (Pressed = Recording 1, Released = Stopped 0)
    initPressed: 'False'
    label: Start / Stop Capture
    pressBackgroundColor: red
    pressFontColor: white
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: capture_status_label
  id: variable_qtgui_label
  parameters:
    comment: Live visual feedback for capture status
    label: 'Capture Status:'
    type: string
    value: '"RECORDING IN PROGRESS..." if bool(capture_enable) else "CAPTURE STOPPED"'
  states: {}
- name: ce_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: f_max
    low_cutoff_freq: f_min
    samp_rate: samp_rate
    type: complex_band_pass
    width: int((f_max-f_min)/10)
    win: window.WIN_HAMMING
  states: {}
- name: center_freq_mhz
  id: variable_qtgui_range
  parameters:
    comment: Center Frequency Adjustment Slider
    label: Center Frequency (MHz)
    start: '8.0'
    step: '1.0'
    stop: '2000'
    value: '100.0'
  states: {}
- name: decimation
  id: variable
  parameters:
    comment: Wideband Hardware Sampling Rate
    value: int(samp_rate/(f_max-f_min))
  states: {}
- name: f_max
  id: variable_qtgui_range
  parameters:
    comment: Hardware RF Gain Slider
    gui_hint: tab@0
    label: Pass Band End
    start: '-int(samp_rate/2)'
    step: 1e3
    stop: int(samp_rate/2)
    value: int(samp_rate*0.3)
    widget: slider
  states: {}
- name: f_min
  id: variable_qtgui_range
  parameters:
    comment: Hardware RF Gain Slider
    gui_hint: tab@0
    label: Pass Band Start
    start: '-int(samp_rate/2)'
    step: 1e3
    stop: int(samp_rate/2)
    value: '-int(samp_rate*0.3)'
    widget: slider
  states: {}
- name: file_prefix
  id: variable_qtgui_entry
  parameters:
    comment: Capture File Path Prefix (without extension)
    label: Capture File Prefix
    type: string
    value: /tmp/wideband_raw_capture
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    comment: Hardware RF Gain Slider
    label: IF Gain (dB)
    start: '0.0'
    step: '1.0'
    stop: '40'
    value: '20'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: Hardware RF Gain Slider
    label: RF Tuner Gain (dB)
    start: '0.0'
    step: '1.0'
    stop: '49.6'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Wideband Hardware Sampling Rate
    value: '2048000'
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    comment: Start/Stop Gated Recording Copy Block
    enabled: bool(capture_enable)
    type: complex
  states: {}
- name: epy_block_sigmf_writer
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr
      import os, json, datetime, sys, traceback

      class blk(gr.basic_block):
          def __init__(self, capture_enable=0, center_freq_mhz=100.0, samp_rate=2048000.0, file_prefix='/tmp/wideband_raw_capture'):
              gr.basic_block.__init__(
                  self,
                  name='SigMF Meta Writer',
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              self.capture_enable = int(capture_enable)
              self.center_freq_mhz = float(center_freq_mhz)
              self.samp_rate = float(samp_rate)
              self.file_prefix = str(file_prefix)
              self.start_datetime = None
              self.log_file = '/tmp/sigmf_meta_writer.log'
              self._log('SigMF Meta Writer initialized. file_prefix=' + str(self.file_prefix))

          def _log(self, msg_str):
              timestamp = datetime.datetime.now().strftime('%Y-%m-%d %H:%M:%S')
              log_line = f'[{timestamp}] {msg_str}\n'
              sys.stderr.write('[SigMF Writer] ' + log_line)
              sys.stderr.flush()
              try:
                  with open(self.log_file, 'a') as f:
                      f.write(log_line)
              except Exception:
                  pass

          def _extract_val(self, msg):
              val = pmt.to_python(msg)
              if isinstance(val, dict):
                  if 'value' in val:
                      val = val['value']
                  elif val:
                      val = list(val.values())[0]
              elif isinstance(val, (tuple, list)):
                  val = val[-1]
              if isinstance(val, bool):
                  return 1 if val else 0
              return int(val)

          def handle_msg(self, msg):
              try:
                  val = self._extract_val(msg)
                  self._log(f'handle_msg received PMT msg value: {val} (current capture_enable={self.capture_enable})')
                  if val == 1:
                      self.start_datetime = datetime.datetime.now(datetime.timezone.utc).isoformat().replace('+00:00', 'Z')
                      self._log(f'Capture STARTED (msg). Recorded start_datetime: {self.start_datetime}')
                  elif val == 0:
                      self._log('Capture STOPPED (msg). Triggering write_meta_file()...')
                      self.write_meta_file()
                  self.capture_enable = val
              except Exception as e:
                  err_msg = f'ERROR in handle_msg: {e}\n{traceback.format_exc()}'
                  self._log(err_msg)

          def set_capture_enable(self, capture_enable):
              try:
                  val = int(capture_enable)
                  self._log(f'set_capture_enable called with val: {val} (current capture_enable={self.capture_enable})')
                  if val == 1:
                      self.start_datetime = datetime.datetime.now(datetime.timezone.utc).isoformat().replace('+00:00', 'Z')
                      self._log(f'Capture STARTED (setter). Recorded start_datetime: {self.start_datetime}')
                  elif val == 0:
                      self._log('Capture STOPPED (setter). Triggering write_meta_file()...')
                      self.write_meta_file()
                  self.capture_enable = val
              except Exception as e:
                  err_msg = f'ERROR in set_capture_enable: {e}\n{traceback.format_exc()}'
                  self._log(err_msg)

          def set_center_freq_mhz(self, center_freq_mhz):
              self.center_freq_mhz = float(center_freq_mhz)
              self._log(f'Center frequency updated: {self.center_freq_mhz} MHz')

          def set_samp_rate(self, samp_rate):
              self.samp_rate = float(samp_rate)
              self._log(f'Sample rate updated: {self.samp_rate} Hz')

          def set_file_prefix(self, file_prefix):
              self.file_prefix = str(file_prefix)
              self._log(f'File prefix updated: {self.file_prefix}')

          def write_meta_file(self):
              try:
                  if not self.start_datetime:
                      self.start_datetime = datetime.datetime.now(datetime.timezone.utc).isoformat().replace('+00:00', 'Z')
                  data_path = self.file_prefix + '.sigmf-data'
                  meta_path = self.file_prefix + '.sigmf-meta'
                  sample_count = 0
                  if os.path.exists(data_path):
                      sample_count = os.path.getsize(data_path) // 8
                  meta_data = {
                      'global': {
                          'core:datatype': 'cf32_le',
                          'core:sample_rate': float(self.samp_rate),
                          'core:version': '1.0.0',
                          'core:description': 'Live RTL-SDR RF pure wideband raw capture',
                          'core:author': 'gr-playground rtlsdr_wideband_frontend'
                      },
                      'captures': [
                          {
                              'core:sample_start': 0,
                              'core:sample_count': int(sample_count),
                              'core:frequency': float(self.center_freq_mhz * 1e6),
                              'core:datetime': self.start_datetime
                          }
                      ],
                      'annotations': []
                  }
                  target_dir = os.path.dirname(os.path.abspath(meta_path))
                  os.makedirs(target_dir, exist_ok=True)
                  with open(meta_path, 'w') as f:
                      json.dump(meta_data, f, indent=2)
                  self._log(f'SUCCESSFULLY WROTE SigMF Metadata -> {meta_path} (Samples: {sample_count:,}, Start: {self.start_datetime})')
              except Exception as e:
                  err_msg = f'ERROR in write_meta_file: {e}\n{traceback.format_exc()}'
                  self._log(err_msg)
    capture_enable: capture_enable
    center_freq_mhz: center_freq_mhz
    comment: Embedded Python Block triggered directly by Toggle Button message output
    file_prefix: file_prefix
    samp_rate: samp_rate
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (f_max+f_min)/2
    decim: decimation
    samp_rate: samp_rate
    taps: ce_taps
    type: ccc
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq_mhz*1e6
    fftsize: '1024'
    gui_hint: tab@0
    name: '"Wideband Spectrum (RTL-SDR)"'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: center_freq_mhz*1e6 + (f_max+f_min)/2
    fftsize: '1024'
    gui_hint: tab@1
    name: '"BaseBand"'
    showrf: 'True'
    type: complex
  states: {}
- name: rtlsdr_source
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    comment: Live RTL-SDR Hardware Source (gr-osmosdr native)
    freq0: center_freq_mhz*1e6
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Tab 0
    label1: Tab 1
    num_tabs: '2'
  states: {}
- name: wideband_file_sink
  id: blocks_file_sink
  parameters:
    comment: Pure Wideband Spectrum File Sink (2.4 MSps Raw SigMF Data)
    file: file_prefix + '.sigmf-data'
    type: complex
  states: {}

connections:
- [blocks_copy_0, '0', wideband_file_sink, '0']
- [capture_enable, state, epy_block_sigmf_writer, msg_in]
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_0_0, '0']
- [rtlsdr_source, '0', blocks_copy_0, '0']
- [rtlsdr_source, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
