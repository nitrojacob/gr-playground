options:
  parameters:
    author: gr-playground agent
    category: '[GRC Hier Blocks]'
    cmake_opt: ''
    comment: Single Unified RTL-SDR Live Capture & Wideband Channelizer Frontend
    copyright: ''
    description: Live RTL-SDR RF capture and wideband file channelizer exporting to SigMF
    gen_cmake: 'On'
    gen_linking: dynamic
    generate_options: qt_gui
    hier_block_src_path: '.:'
    id: rtlsdr_wideband_frontend
    max_nouts: '0'
    output_language: python
    placement: (0,0)
    qt_qss_theme: ''
    realtime_scheduling: ''
    run: 'True'
    run_command: '{python} -u {filename}'
    run_options: prompt
    sizing_mode: fixed
    thread_safe_setters: ''
    title: RTL-SDR Wideband Capture & Channelizer Frontend
    window_size: (1280, 1024)

blocks:
- block_id: variable_qtgui_range
  parameters:
    comment: ''
    gui_hint: ''
    label: Channel Offset (Hz)
    min_len: '200'
    orient: QtCore.Qt.Horizontal
    range_Type: float
    start: -1000000.0
    step: '1000.0'
    stop: '1000000.0'
    value: '200000.0'
    widget: counter_slider
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [280, 12]
    rotation: 0
    state: enabled

- block_id: variable_qtgui_range
  parameters:
    comment: ''
    gui_hint: ''
    label: Channel Cutoff (Hz)
    min_len: '200'
    orient: QtCore.Qt.Horizontal
    range_Type: float
    start: '5000.0'
    step: '2500.0'
    stop: '250000.0'
    value: '60000.0'
    widget: counter_slider
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [460, 12]
    rotation: 0
    state: enabled

- block_id: variable
  parameters:
    comment: ''
    value: '2400000'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [180, 12]
    rotation: 0
    state: enabled
  id: samp_rate

- block_id: variable_low_pass_filter_taps
  parameters:
    beta: '6.76'
    comment: ''
    cutoff_freq: channel_cutoff
    gain: '1.0'
    samp_rate: samp_rate
    width: channel_cutoff * 0.2
    win: window.WIN_HAMMING
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [640, 12]
    rotation: 0
    state: enabled
  id: lpf_taps

- block_id: soapy_rtlsdr_source
  parameters:
    affinity: ''
    alias: ''
    center_freq: 100.0e6
    comment: Live RTL-SDR Hardware Capture Source
    dev_args: ''
    freq_correction: '0'
    gain: '20'
    maxoutbuf: '0'
    minoutbuf: '0'
    samp_rate: samp_rate
    type: fc32
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [40, 180]
    rotation: 0
    state: enabled
  id: rtlsdr_source

- block_id: qtgui_freq_sink_x
  parameters:
    affinity: ''
    alias: ''
    alpha1: '1.0'
    alpha10: '1.0'
    alpha2: '1.0'
    alpha3: '1.0'
    alpha4: '1.0'
    alpha5: '1.0'
    alpha6: '1.0'
    alpha7: '1.0'
    alpha8: '1.0'
    alpha9: '1.0'
    autoscale: 'False'
    average: '0.2'
    color1: '"blue"'
    color10: '"dark blue"'
    color2: '"red"'
    color3: '"green"'
    color4: '"black"'
    color5: '"cyan"'
    color6: '"magenta"'
    color7: '"yellow"'
    color8: '"dark red"'
    color9: '"dark green"'
    comment: Wideband Spectrum Visualizer
    ctrlpanel: 'False'
    fc: 100.0e6
    fftsize: '2048'
    freqhalf: 'True'
    grid: 'True'
    gui_hint: ''
    label: Relative Gain
    label1: Wideband Spectrum
    label10: ''
    label2: ''
    label3: ''
    label4: ''
    label5: ''
    label6: ''
    label7: ''
    label8: ''
    label9: ''
    legend: 'True'
    maxoutbuf: '0'
    minoutbuf: '0'
    name: '"Wideband Spectrum (RTL-SDR)"'
    nconnections: '1'
    norm_maxk: '-1'
    showports: 'False'
    tr_chan: '0'
    tr_level: '0.0'
    tr_mode: qtgui.TRIG_MODE_FREE
    tr_tag: '""'
    type: complex
    units: dB
    update_time: '0.10'
    width1: '1'
    width10: '1'
    width2: '1'
    width3: '1'
    width4: '1'
    width5: '1'
    width6: '1'
    width7: '1'
    width8: '1'
    width9: '1'
    wmax: ''
    wmin: ''
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [320, 150]
    rotation: 0
    state: enabled
  id: qtgui_freq_sink

- block_id: filter_freq_xlating_fir_filter_ccc
  parameters:
    affinity: ''
    alias: ''
    center_freq: channel_freq_offset
    comment: Digital Downconverter (DDC) Channelizer
    decim: '10'
    maxoutbuf: '0'
    minoutbuf: '0'
    samp_rate: samp_rate
    taps: lpf_taps
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [320, 270]
    rotation: 0
    state: enabled
  id: freq_xlating_filter

- block_id: analog_agc2_cc
  parameters:
    affinity: ''
    alias: ''
    attack_rate: 1e-3
    comment: Automatic Gain Control
    decay_rate: 1e-2
    gain: '1.0'
    max_gain: '65536'
    maxoutbuf: '0'
    minoutbuf: '0'
    reference: '1.0'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [580, 270]
    rotation: 0
    state: enabled
  id: agc

- block_id: blocks_file_sink
  parameters:
    affinity: ''
    alias: ''
    append: 'False'
    comment: Export Extracted Narrowband Channel to SigMF Data
    file: /tmp/extracted_channel.sigmf-data
    type: complex
    unbuffered: 'False'
    vlen: '1'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [780, 270]
    rotation: 0
    state: enabled
  id: sigmf_file_sink

connections:
- [rtlsdr_source, '0', qtgui_freq_sink, '0']
- [rtlsdr_source, '0', freq_xlating_filter, '0']
- [freq_xlating_filter, '0', agc, '0']
- [agc, '0', sigmf_file_sink, '0']

metadata:
  file_format: 1
